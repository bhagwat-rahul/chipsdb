VERSION 5.8 ;
UNITS
  DATABASE MICRONS 1000 ;
END UNITS

LAYER M1
  TYPE ROUTING ;
  DIRECTION HORIZONTAL ;
  PITCH 0.20 ;
  WIDTH 0.10 ;
  SPACING 0.10 ;
END M1

END LIBRARY


